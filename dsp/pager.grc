options:
  parameters:
    author: toa
    generate_options: qt_gui
    id: pager
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: '12'
  states: {}
- name: hw_freq
  id: variable
  parameters:
    value: 157.9e6
  states: {}
- name: lpf
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: rtl_samp_rate / (2*decimation)
    gain: '1.0'
    samp_rate: rtl_samp_rate
    width: '5000'
    win: window.WIN_HAMMING
  states: {}
- name: rtl_samp_rate
  id: variable
  parameters:
    value: '264600'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: rtl_samp_rate // decimation
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '0.2'
    max_gain: '65536'
    rate: '1e-4'
    reference: '0.2'
    type: float
  states: {}
- name: analog_agc_xx_0_0
  id: analog_agc_xx
  parameters:
    gain: '0.2'
    max_gain: '65536'
    rate: '1e-4'
    reference: '0.2'
    type: float
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: samp_rate
    max_dev: 5e3
    quad_rate: samp_rate
    tau: '50e-6'
  states: {}
- name: analog_nbfm_rx_0_0_0_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: samp_rate
    max_dev: 5e3
    quad_rate: samp_rate
    tau: '50e-6'
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '8192'
  states: {}
- name: blocks_float_to_short_0_0
  id: blocks_float_to_short
  parameters:
    scale: '8192'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 157.95e6 - hw_freq
    decim: decimation
    samp_rate: rtl_samp_rate
    taps: lpf
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 157.925e6 - hw_freq
    decim: decimation
    samp_rate: rtl_samp_rate
    taps: lpf
    type: ccc
  states: {}
- name: iio_attr_sink_0
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: RX_LO
    device: ad9361-phy
    output: 'True'
    uri: iio_context
  states: {}
- name: iio_attr_updater_0
  id: iio_attr_updater
  parameters:
    attr: powerdown
    interval: '1000'
    value: '0'
  states: {}
- name: iio_context
  id: parameter
  parameters:
    label: IIO Context
    type: str
    value: ip:pluto.local
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: rtl_samp_rate
    bbdc: 'True'
    buffer_size: rtl_samp_rate // 4
    filter_source: '''Auto'''
    frequency: int(hw_freq)
    gain1: '''manual'''
    manual_gain1: '50'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: rtl_samp_rate
    type: fc32
    uri: iio_context
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    axislabels: 'False'
    bw: rtl_samp_rate
    fc: '0'
    fftsize: '1024'
    legend: 'False'
    type: complex
    update_time: '0.01'
    ymax: '-30'
    ymin: '-110'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    gui_hint: '[0,0]'
    int_max: '-30'
    int_min: '-110'
    name: CH1
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    gui_hint: '[0,1]'
    int_max: '-30'
    int_min: '-110'
    name: CH2
    type: complex
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: ipc:///tmp/pager_ch1.socket
    drop_on_hwm: 'False'
    timeout: '500'
    type: short
  states: {}
- name: zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: ipc:///tmp/pager_ch2.socket
    drop_on_hwm: 'False'
    timeout: '500'
    type: short
  states: {}

connections:
- [analog_agc_xx_0, '0', blocks_float_to_short_0, '0']
- [analog_agc_xx_0_0, '0', blocks_float_to_short_0_0, '0']
- [analog_nbfm_rx_0, '0', analog_agc_xx_0, '0']
- [analog_nbfm_rx_0_0_0_0, '0', analog_agc_xx_0_0, '0']
- [blocks_float_to_short_0, '0', zeromq_pub_sink_0, '0']
- [blocks_float_to_short_0_0, '0', zeromq_pub_sink_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_nbfm_rx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', analog_nbfm_rx_0_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [iio_attr_updater_0, out, iio_attr_sink_0, attr]
- [iio_pluto_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [iio_pluto_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
