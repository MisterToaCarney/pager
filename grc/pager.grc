options:
  parameters:
    author: toa
    generate_options: qt_gui
    id: pager
    output_language: python
    realtime_scheduling: '1'
    title: Not titled yet
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: '11'
  states: {}
- name: hw_freq
  id: variable
  parameters:
    value: 157.95e6
  states: {}
- name: lpf
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: rtl_samp_rate / (2*decimation)
    gain: '1.0'
    samp_rate: rtl_samp_rate
    width: '5000'
    win: window.WIN_HAMMING
  states: {}
- name: rtl_samp_rate
  id: variable
  parameters:
    value: '242550'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: rtl_samp_rate // decimation
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: samp_rate
    max_dev: 5e3
    quad_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: analog_nbfm_rx_0_0_0_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: samp_rate
    max_dev: 5e3
    quad_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '8192'
  states: {}
- name: blocks_float_to_short_0_0
  id: blocks_float_to_short
  parameters:
    scale: '8192'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 157.95e6 - hw_freq
    decim: decimation
    samp_rate: rtl_samp_rate
    taps: lpf
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 157.925e6 - hw_freq
    decim: decimation
    samp_rate: rtl_samp_rate
    taps: lpf
    type: ccc
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: '[0,0]'
    int_max: '-10'
    int_min: '-90'
    name: CH1
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: '[0,1]'
    int_max: '-10'
    int_min: '-90'
    name: CH2
    type: complex
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: hw_freq
    gain0: '18'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: rtl_samp_rate
    sync: sync
    type: fc32
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: ipc:///tmp/pager_ch1.socket
    drop_on_hwm: 'False'
    timeout: '500'
    type: short
  states: {}
- name: zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: ipc:///tmp/pager_ch2.socket
    drop_on_hwm: 'False'
    timeout: '500'
    type: short
  states: {}

connections:
- [analog_nbfm_rx_0, '0', blocks_float_to_short_0, '0']
- [analog_nbfm_rx_0_0_0_0, '0', blocks_float_to_short_0_0, '0']
- [blocks_float_to_short_0, '0', zeromq_pub_sink_0, '0']
- [blocks_float_to_short_0_0, '0', zeromq_pub_sink_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_nbfm_rx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', analog_nbfm_rx_0_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
